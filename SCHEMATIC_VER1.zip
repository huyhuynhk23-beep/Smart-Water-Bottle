# Altium schematic sheet BLOCKDIAGRAM.SchDoc
size 420 x 297 mm

## Notes on the sheet
- BLOCK DIAGRAM
- GPIO
- I2C